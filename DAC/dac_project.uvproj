# Keil uVision project dac_project.uvproj, settings and files
target Target 1 (MCS-51)
  device: ADuC831 Analog Devices
  cpu: IRAM(0-0xFF) IROM(0-0xF7FF) XRAM (0-0x7FF) CLOCK(12000000) DPX MODAB2
  output: dac_project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c ADuC831.h uart_io.h uart_io.c std_types.h libs.h data_integrity.h custom_types.h math_utils.h math_utils.c data_integrity.c
